# Keil uVision project GD32303C_EVAL.uvproj, settings and files
target GD32F303C_EVAL (ARM-ADS)
  device: GD32F303VC GigaDevice
  cpu: IRAM(0x20000000-0x2000BFFF)IROM(0x08000000-0x0803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4")
  output: Project +hex
  c flags: oTime=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD
  c misc: --gnu -Dlittle_endian
  c include: ..\Library\Firmware\CMSIS;..\Library\Firmware\CMSIS\GD\GD32F30x\Include;..\Library\Firmware\GD32F30x_standard_peripheral\Include;..\Library\Utilities;..\;..\Bsp\include;..\hilink_mcu_sdk\include;..\hilink_mcu_sdk\system\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application
    ../: main.c gd32f30x_it.c systick.c
  group Bsp
    ../Bsp/: uart.c led.c key.c timer.c
  group CMSIS
    ../Library/Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group GD32F30x_Peripherals
    ../Library/Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group hilink_mcu_sdk
    ../hilink_mcu_sdk/: hilink_device.c hilink_mcu.c hilink_ota.c
  group hilink_mcu_sdk.system
    ../hilink_mcu_sdk/system/: hilink_hislip.c hilink_mcu_main.c hilink_process.c
  group Startup
    ../Library/Firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
  group Doc
    ../: readme.txt
